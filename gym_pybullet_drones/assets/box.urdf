Commit message: add TransportAviary Env

File: gym_pybullet_drones/assets/box.urdf (robot description, URDF)
Before this commit: robot test.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .1 -> 0.01; geometry collision box size=0.1 0.1 .05; visual box size=0.1 0.1 .05
